# Keil uVision project STL_Single_Tests_TZ_S.uvprojx, settings and files
target STL_Single_Tests_TZ_S (6190000::V6.19::ARMCLANG)
  device: STM32H563ZITx STMicroelectronics
  pack: Keil.STM32H5xx_DFP.1.2.0
  cpu: IRAM(0x30000000-0x3004FFFF) IROM(0x0C000000-0xC0FDFFF) IROM2(0x0C0FE000-0xC0FFFFF) CLOCK(8000000) FPU3(SFPU) CPUTYPE("Cortex-M33") ELITTLE TZ DSP
  output: Project +hex
  BeforeMake: cmd /c "if exist Out\Project.axf del Out\Project.axf"
  AfterMake: STM32_Programmer_CLI.exe -sl "Out/Project.axf" 0x0C000000 0x0C100000 0x400
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32H563xx,STL_EVAL_MODE
  c include: ../../Secure/Inc;../../Secure_nsclib;../../../../../../../Drivers/STM32H5xx_HAL_Driver/Inc;../../../../../../../Drivers/CMSIS/Device/ST/STM32H5xx/Include;../../../../../../../Drivers/STM32H5xx_HAL_Driver/Inc/Legacy;../../../../../../../Drivers/CMSIS/Include;..\..\..\..\..\..\..\Drivers\BSP\STM32H5xx_Nucleo;..\..\..\..\..\..\..\Middlewares\ST\STM32_Safety_STL\Inc
  memory RVCT4: ROM 0xc000000 size 0xfe000
  memory RVCT5: ROM 0xc0fe000 size 0x2000
  memory RVCT9: RAM 0x30000000 size 0x50000
  scatter file: Project.sct
  link misc: --import_cmse_lib_out=../../Secure_nsclib/secure_nsclib.o
  group Application/MDK-ARM
    ../: startup_stm32h563xx.s
  group Application/User/Secure
    ../../Secure/Src/: main.c stm32h5xx_it.c stm32h5xx_hal_msp.c secure_nsc.c
  group Drivers/STM32H5xx_HAL_Driver
    ../../../../../../../Drivers/STM32H5xx_HAL_Driver/Src/: stm32h5xx_hal_cortex.c stm32h5xx_hal_gtzc.c stm32h5xx_hal_rcc.c stm32h5xx_hal_rcc_ex.c stm32h5xx_hal_flash.c stm32h5xx_hal_flash_ex.c stm32h5xx_hal_gpio.c stm32h5xx_hal_dma.c stm32h5xx_hal_dma_ex.c stm32h5xx_hal_pwr.c stm32h5xx_hal_pwr_ex.c stm32h5xx_hal.c stm32h5xx_hal_exti.c stm32h5xx_hal_tim.c stm32h5xx_hal_tim_ex.c stm32h5xx_hal_icache.c
  group Drivers/CMSIS
    ../../Secure/Src/: system_stm32h5xx_s.c
  group Drivers/BSP/STM32H5xx_Nucleo
    ../../../../../../../Drivers/BSP/STM32H5xx_Nucleo/: stm32h5xx_nucleo.c
  group Middlewares/ST/STM32_Safety_STL
    ../../../../../../../Middlewares/ST/STM32_Safety_STL/Lib/: STL_Lib.a
    ../../../../../../../Middlewares/ST/STM32_Safety_STL/Src/: stl_user_param_template.c stl_util.c
software components: CMSIS:CORE 4.3.0
