# IAR project STL_Single_Tests_No_TZ.ewp, settings and files
configuration stl_single_tests_no_tz (ARM, debug)
  General.OGChipSelectEditMenu: STM32H563ZI ST STM32H563ZI
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 61
  General.FPU2: 6
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32H563xx; STL_EVAL_MODE
  ICCARM.CCIncludePath2: ../../NoTrustZone/Inc; ../../../../../../../Drivers/STM32H5xx_HAL_Driver/Inc; ../../../../../../../Drivers/STM32H5xx_HAL_Driver/Inc/Legacy; ../../../../../../../Drivers/CMSIS/Device/ST/STM32H5xx/Include; ../../../../../../../Drivers/CMSIS/Include; ../../../../../../../Middlewares/ST/STM32_Safety_STL/Inc; ../../../../../../../Drivers/BSP/STM32H5xx_Nucleo/
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: stl_single_tests_no_tz.hex
  ILINK.IlinkOutputFile: stl_single_tests_no_tz.out
  ILINK.IlinkIcfFile: stm32h563xx_flash.icf
  ILINK.IlinkAdditionalLibs: ..\..\..\..\..\..\..\Middlewares\ST\STM32_Safety_STL\Lib\STL_Lib.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ../: startup_stm32h563xx.s
    ./: stm32h563xx_flash.icf
  group Application/User
    ../../NoTrustZone/Src/: main.c stm32h5xx_hal_msp.c stm32h5xx_it.c
  group Drivers/BSP/STM32H5xx_Nucleo
    ../../../../../../../Drivers/BSP/STM32H5xx_Nucleo/: stm32h5xx_nucleo.c
  group Drivers/CMSIS
    ../../NoTrustZone/Src/: system_stm32h5xx.c
  group Drivers/STM32H5xx_HAL_Driver
    ../../../../../../../Drivers/STM32H5xx_HAL_Driver/Src/: stm32h5xx_hal.c stm32h5xx_hal_cortex.c stm32h5xx_hal_dma.c stm32h5xx_hal_dma_ex.c stm32h5xx_hal_exti.c stm32h5xx_hal_flash.c stm32h5xx_hal_flash_ex.c stm32h5xx_hal_gpio.c stm32h5xx_hal_icache.c stm32h5xx_hal_pwr.c stm32h5xx_hal_pwr_ex.c stm32h5xx_hal_rcc.c stm32h5xx_hal_rcc_ex.c stm32h5xx_hal_tim.c stm32h5xx_hal_tim_ex.c
  group Middlewares/ST/STM32_Safety_STL
    ../../../../../../../Middlewares/ST/STM32_Safety_STL/Src/: stl_user_param_template.c stl_util.c
