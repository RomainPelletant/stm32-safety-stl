# Keil uVision project Project.uvprojx, settings and files
target NUCLEO-G071RB_STL_Single_Tests (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32G071RBTx STMicroelectronics
  pack: Keil.STM32G0xx_DFP.1.4.0
  cpu: IROM(0x08000000-0x801FFFF) IRAM(0x20000000-0x20008FFF) CLOCK(8000000) CPUTYPE("Cortex-M0+")
  output: Project
  AfterMake: STM32_Programmer_CLI.exe -sl "./NUCLEO-G071RB/Exe/Project.axf" 0x08000000 0x08020000 0x400
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32G071xx,USE_HAL_DRIVER,STL_EVAL_MODE
  c misc: --wchar32
  c include: ../Inc;../../../../../../Drivers/CMSIS/Device/ST/STM32G0xx/Include;../../../../../../Drivers/STM32G0xx_HAL_Driver/Inc;../../../../../../Drivers/BSP/STM32G0xx_Nucleo;../../../../../../Drivers/BSP/Components/Common;../../../../../../Middlewares/ST/STM32_Safety_STL/Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x9000
  scatter file: NUCLEO-G071RB\Exe\Project.sct
  group Doc
    ../: readme.txt
  group Application/User
    ../Src/: main.c stm32g0xx_it.c stm32g0xx_hal_msp.c
  group Application/MDK-ARM
    ./: startup_stm32g071xx.s
  group Drivers/BSP/STM32G0xx_Nucleo
    ../../../../../../Drivers/BSP/STM32G0xx_Nucleo/: stm32g0xx_nucleo.c
  group Drivers/STM32G0xx_HAL_Driver
    ../../../../../../Drivers/STM32G0xx_HAL_Driver/Src/: stm32g0xx_hal.c stm32g0xx_hal_cortex.c stm32g0xx_hal_gpio.c stm32g0xx_hal_rcc.c stm32g0xx_hal_rcc_ex.c stm32g0xx_hal_flash.c stm32g0xx_hal_flash_ex.c stm32g0xx_hal_pwr.c stm32g0xx_hal_pwr_ex.c stm32g0xx_hal_tim.c stm32g0xx_hal_tim_ex.c stm32g0xx_hal_dma.c stm32g0xx_hal_dma_ex.c
  group Drivers/CMSIS
    ../Src/: system_stm32g0xx.c
  group Middlewares/ST/STM32_Safety_STL
    ../../../../../../Middlewares/ST/STM32_Safety_STL/Src/: stl_user_param_template.c stl_util.c
  group Middlewares/ST/STM32_Safety_STL/Lib
    ../../../../../../Middlewares/ST/STM32_Safety_STL/Lib/: STL_Lib.a
software components: CMSIS:CORE 5.5.0
