# IAR project Project.ewp, settings and files
configuration NUCLEO-G071RB_STL_Single_Tests (ARM, debug)
  General.OGChipSelectEditMenu: STM32G071RB ST STM32G071RB
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: STM32G071xx; USE_HAL_DRIVER; STL_EVAL_MODE
  ICCARM.CCIncludePath2: ..\Inc; ..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32G0xx\Include; ..\..\..\..\..\..\Drivers\STM32G0xx_HAL_Driver\Inc; ..\..\..\..\..\..\Drivers\BSP\STM32G0xx_Nucleo; ..\..\..\..\..\..\Drivers\BSP\Components\Common; ..\..\..\..\..\..\Middlewares\ST\STM32_Safety_STL\Inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Project.srec
  postbuild: STM32_Programmer_CLI.exe -sl "NUCLEO-G071RB\Exe\Project.out" 0x08000000 0x08020000 0x400
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkIcfFile: stm32g071xx_flash.icf
  ILINK.IlinkAdditionalLibs: ..\..\..\..\..\..\Middlewares\ST\STM32_Safety_STL\Lib\STL_Lib.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32g071xx.s
  group Application/User
    ../Src/: main.c stm32g0xx_hal_msp.c stm32g0xx_it.c
  group Doc
    ../: readme.txt
  group Drivers/BSP/STM32G0xx_Nucleo
    ../../../../../../Drivers/BSP/STM32G0xx_Nucleo/: stm32g0xx_nucleo.c
  group Drivers/CMSIS
    ../Src/: system_stm32g0xx.c
  group Drivers/STM32G0xx_HAL_Driver
    ../../../../../../Drivers/STM32G0xx_HAL_Driver/Src/: stm32g0xx_hal.c stm32g0xx_hal_cortex.c stm32g0xx_hal_flash.c stm32g0xx_hal_flash_ex.c stm32g0xx_hal_gpio.c stm32g0xx_hal_pwr.c stm32g0xx_hal_pwr_ex.c stm32g0xx_hal_rcc.c stm32g0xx_hal_rcc_ex.c stm32g0xx_hal_tim.c stm32g0xx_hal_tim_ex.c
  group Middlewares/ST/STM32_Safety_STL
    ../../../../../../Middlewares/ST/STM32_Safety_STL/Src/: stl_user_param_template.c stl_util.c
